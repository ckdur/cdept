v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
